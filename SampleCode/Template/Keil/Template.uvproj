# Keil uVision project Template.uvproj, settings and files
target Master (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M0A23EC1AC Nuvoton
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0x7FFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: USCI_SPI_MASTER +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USCI_SPI_MASTER
  c include: ..\..\..\Library\CMSIS\Include;..\..\..\Library\Device\Nuvoton\M0A21\Include;..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --map --first='startup_M0A21.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/M0A21/Source/: system_M0A21.c
    ../../../Library/Device/Nuvoton/M0A21/Source/ARM/: startup_M0A21.s
  group Library
    ../../../Library/StdDriver/src/: retarget.c uart.c clk.c timer.c sys.c gpio.c usci_spi.c pdma.c
  group User
    ../: main.c
target Slave (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M0A23EC1AC Nuvoton
  cpu: as above
  output: USCI_SPI_SLAVE +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USCI_SPI_SLAVE
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: as above
